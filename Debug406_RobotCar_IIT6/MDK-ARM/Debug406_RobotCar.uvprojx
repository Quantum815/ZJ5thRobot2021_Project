# Keil uVision project Debug406_RobotCar.uvprojx, settings and files
target Debug406_RobotCar (6150000::V6.15::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Debug406_RobotCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H743xx,USE_HAL_DRIVER
  c include: ../Core/Inc;                                                 ../Drivers/STM32H7xx_HAL_Driver/Inc;                                                 ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                                                 ../Drivers/CMSIS/Include;                                                 ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                                                 ..\MyFiles\Inc;                                                 ..\MyDrivers\Inc;                                                 ..\MyMiddleware\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c i2c.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/MyFiles
    ../MyFiles/Src/: Miscellaneous.c UserMain.c UserFsmFrame.c UserFsmCondition.c UserFsmJump.c
  group Application/User/Doc
    ../../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Driver/MyMiddleware
    ../MyMiddleware/Src/: BasicAction.c CallBackAction.c
  group Drivers/MyDrivers
    ../MyDrivers/Src/: Gyro.c GraySensor.c DiffuseReflectionLaser.c RangingLaser.c InductiveMotor.c ServoMotor.c MatrixKeyBoard.c ImageProcess.c
software components: CMSIS:CORE 5.4.0
